/*
 * versig.c - Sigmastar
 *
 * Copyright (c) [2019~2020] SigmaStar Technology.
 *
 *
 * This software is licensed under the terms of the GNU General Public
 * License version 2, as published by the Free Software Foundation, and
 * may be copied, distributed, and modified under those terms.
 *
 * This program is distributed in the hope that it will be useful,
 * but WITHOUT ANY WARRANTY; without even the implied warranty of
 * MERCHANTABILITY or FITNESS FOR A PARTICULAR PURPOSE.  See the
 * GNU General Public License version 2 for more details.
 *
 */

#include <common.h>
#include <log.h>
#include <command.h>
#include <tee.h>
#include <stdlib.h>
#include <asm/arch/mach/io.h>
#include <asm/arch/mach/platform.h>
#include <sstar_sys_utility.h>

#define TA_VERSIG_UUID                                     \
    {                                                      \
        0x583bf7f6, 0x136e, 0x4bab,                        \
        {                                                  \
            0x89, 0x6b, 0x66, 0x01, 0x3a, 0xc8, 0xf7, 0x7a \
        }                                                  \
    }

/*
 * in	params[0].tmpref.buffer message buffer
 * in	params[1].tmpref.buffer signature buffer
 */

#define TA_VERSIG_CMD_VERIFY 0

uint8_t msg[] = {0x31, 0x32, 0x33, 0x34, 0x35, 0x36};

uint8_t sig[] = {
    0x4B, 0xA3, 0x23, 0xD5, 0x5F, 0x33, 0x90, 0xB7, 0x6B, 0x28, 0xA7, 0xA2, 0xFD, 0x59, 0x86, 0x22, 0x7C, 0x7D, 0x9F,
    0x9D, 0x22, 0x1A, 0xC9, 0xB4, 0xFC, 0x75, 0x88, 0x29, 0x04, 0x93, 0x59, 0xF7, 0xF7, 0xFA, 0x05, 0xEC, 0x58, 0x53,
    0xF1, 0xD6, 0x26, 0x79, 0xC0, 0x3B, 0xBF, 0x77, 0xA9, 0xFC, 0x13, 0xB2, 0x45, 0x1D, 0xFA, 0xA5, 0x42, 0x12, 0x60,
    0x41, 0xE9, 0xFF, 0x45, 0xC6, 0xCD, 0xFC, 0xC3, 0x55, 0x00, 0x33, 0x72, 0x9F, 0xD2, 0xC3, 0x66, 0xB5, 0x4A, 0xA1,
    0x80, 0xFE, 0x2F, 0xCC, 0x55, 0x84, 0x62, 0x23, 0x95, 0x3E, 0x23, 0xA6, 0xA6, 0x71, 0xC3, 0xBB, 0xBA, 0x51, 0xA0,
    0x77, 0x90, 0xA2, 0x62, 0x03, 0xEA, 0x0A, 0xA5, 0xEB, 0xA7, 0x27, 0x2A, 0x92, 0x1C, 0x49, 0xC1, 0xC7, 0xD4, 0x72,
    0x06, 0xFD, 0xD1, 0x3F, 0x98, 0x4E, 0xDB, 0x14, 0xFE, 0xCC, 0xD4, 0x5D, 0x08, 0xD6, 0xCD, 0x9E, 0xDD, 0xBF, 0x31,
    0x9D, 0xDD, 0xC8, 0x13, 0x46, 0xD8, 0x0C, 0xA9, 0x46, 0xF1, 0xE6, 0xA7, 0x30, 0xDF, 0x5E, 0x8F, 0x6E, 0x61, 0xEA,
    0x5F, 0x33, 0x7E, 0x48, 0x98, 0xD7, 0x56, 0xFC, 0xD5, 0x5E, 0x6A, 0x98, 0x58, 0x81, 0x1F, 0xC0, 0x49, 0x04, 0x40,
    0x7B, 0x41, 0xFC, 0xF9, 0xD5, 0x58, 0x02, 0x01, 0x3B, 0xF8, 0xA6, 0xDE, 0xAE, 0x11, 0xF5, 0x95, 0x38, 0xDE, 0x50,
    0x3F, 0xB5, 0x20, 0xA5, 0x0D, 0xF9, 0xFC, 0xA7, 0x58, 0x05, 0x35, 0x03, 0x9A, 0x8C, 0xAF, 0xCC, 0x25, 0xD1, 0xD3,
    0xCD, 0xBC, 0x53, 0x5A, 0x9C, 0x23, 0x2C, 0xD0, 0xEC, 0xA7, 0xCD, 0xE2, 0x18, 0x94, 0x5C, 0xF1, 0xA1, 0x56, 0x2A,
    0xD7, 0x14, 0x8A, 0x0E, 0x81, 0xA2, 0x0C, 0x0D, 0xB7, 0x9A, 0xEF, 0xDF, 0x57, 0xDA, 0x23, 0xEA, 0x93, 0x9F, 0x92,
    0xF1, 0xD7, 0xCF, 0x3C, 0x8D, 0x73, 0xC5, 0x9B, 0x65,
};

int do_versig(struct cmd_tbl *cmdtp, int flag, int argc, char *const argv[])
{
    const struct tee_optee_ta_uuid uuid = TA_VERSIG_UUID;
    struct tee_open_session_arg    session;
    struct tee_invoke_arg          invoke;
    struct tee_param               param[4];
    struct udevice *               tee = NULL;

    struct tee_shm *msg_buf;
    size_t          msg_buf_size = sizeof(msg);
    struct tee_shm *sig_buf;
    size_t          sig_buf_size = sizeof(sig);
    int             rc;

    tee = tee_find_device(tee, NULL, NULL, NULL);
    if (!tee)
    {
        printf("find device fail\n");
        return -ENODEV;
    }

    memset(&session, 0, sizeof(session));
    tee_optee_ta_uuid_to_octets(session.uuid, &uuid);
    if (tee_open_session(tee, &session, 0, NULL))
    {
        printf("open session fail\n");
        return -ENXIO;
    }
    else
        printf("open session success\n");

    rc = tee_shm_alloc(tee, msg_buf_size, TEE_SHM_ALLOC, &msg_buf);
    if (rc)
        return -ENXIO;

    rc = tee_shm_alloc(tee, sig_buf_size, TEE_SHM_ALLOC, &sig_buf);
    if (rc)
        return -ENXIO;

    memcpy(msg_buf->addr, msg, msg_buf_size);
    memcpy(sig_buf->addr, sig, sig_buf_size);

    memset(&param, 0, sizeof(param));
    param[0].attr          = TEE_PARAM_ATTR_TYPE_MEMREF_INPUT;
    param[0].u.memref.shm  = (struct tee_shm *)msg_buf;
    param[0].u.memref.size = msg_buf_size;
    param[1].attr          = TEE_PARAM_ATTR_TYPE_MEMREF_INPUT;
    param[1].u.memref.shm  = (struct tee_shm *)sig_buf;
    param[1].u.memref.size = sig_buf_size;

    memset(&invoke, 0, sizeof(invoke));
    invoke.func    = TA_VERSIG_CMD_VERIFY;
    invoke.session = session.session;

    if (tee_invoke_func(tee, &invoke, 2, param))
    {
        printf("invoke function fail\n");
        return -EIO;
    }
    else
        printf("invoke function success\n");

    if (invoke.ret == TEE_SUCCESS)
        printf("verify signature success\n");
    else
        printf("verify signature failed, ret=0x%x\n", invoke.ret);

    tee_close_session(tee, session.session);

    return CMD_RET_SUCCESS;
}

U_BOOT_CMD(versig, 1, 1, do_versig, "versig command", "verify signature example\n");
